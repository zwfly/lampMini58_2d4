# Keil uVision project project.uvproj, settings and files
target lamp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Mini58FDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: lamp +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\Library\StdDriver\inc;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\Mini58Series\Include;..\Bsp;..\Bsp\inc;..\utils\inc;..\App\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini58Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group App
    ../App/src/: main.c app_crc.c
  group Bsp
    ../Bsp/: bsp.c
    ../Bsp/src/: bsp_uart.c bsp_key.c bsp_relay.c
  group Utils
    ../utils/src/: lite-log.c
  group CMSIS
    ../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group Library
    ../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
